# Keil uVision project Forcreality.uvprojx, settings and files
target firmware_Release (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.2
  cpu: IRAM(0x1FFF8000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: firmware
  AfterMake: c:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  .\bin\firmware.bin  .\list\firmware.axf
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: HC32F46x,USE_DEVICE_DRIVER_LIB,__TARGET_FPU_VFP,__FPU_PRESENT=1,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__MPU_PRESENT=1,__STM32F1__,STM32_HIGH_DENSITY,ARDUINO_ARCH_STM32F1,ARDUINO_ARCH_STM32
  c misc: --gnu --diag_suppress=186,66 --cpp11
  c include: ..\source\compoment\adc;..\source\compoment\i2c;..\source\compoment\sdio;..\source\compoment\sdio\sd_card\inc;..\source\compoment\spi;..\source\compoment\uart;..\source\compoment\Utility;..\source\drivers\board;..\source\drivers\library;..\source\drivers\library\inc;..\source\framework\cores;..\source\framework\U8glib-HAL;..\source\framework\U8glib-HAL\clib;..\source\framework\U8glib-HAL\clib\HAL_example_files;..\source\main;..\source\main\hdsc32core;..\source\marlin;..\source\marlin\src;..\source\marlin\src\core;..\source\marlin\src\feature;..\source\marlin\src\gcode;..\source\marlin\src\HAL;..\source\marlin\src\HAL\shared;..\source\marlin\src\pins;..\source\marlin\src\HAL\shared\backtrace;..\source\marlin\src\HAL\shared\cpu_exception;..\source\marlin\src\HAL\STM32F1;..\source\marlin\src\HAL\STM32F1\inc;..\source\marlin\src\HAL\STM32F1\tft;..\source\marlin\src\inc;..\source\marlin\src\lcd;..\source\marlin\src\lcd\dogm;..\source\marlin\src\lcd\dogm\fontdata;..\source\marlin\src\lcd\dogm\status;..\source\marlin\src\lcd\dwin;..\source\marlin\src\lcd\dwin\e3v2;..\source\marlin\src\lcd\extui;..\source\marlin\src\lcd\language;..\source\marlin\src\lcd\menu;..\source\marlin\src\libs;..\source\marlin\src\module;..\source\marlin\src\module\stepper;..\source\marlin\src\module\thermistor;..\source\marlin\src\pins;..\source\marlin\src\pins\stm32f1;..\source\marlin\src\sd
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --keep=*Handler
  group drivers
    ../source/drivers/library/src/: hc32f46x_adc.c hc32f46x_aes.c hc32f46x_can.c hc32f46x_clk.c hc32f46x_cmp.c hc32f46x_crc.c hc32f46x_dcu.c hc32f46x_dmac.c hc32f46x_efm.c hc32f46x_emb.c hc32f46x_event_port.c hc32f46x_exint_nmi_swi.c hc32f46x_gpio.c hc32f46x_hash.c hc32f46x_i2c.c hc32f46x_i2s.c hc32f46x_icg.c hc32f46x_interrupts.c hc32f46x_keyscan.c hc32f46x_mpu.c hc32f46x_ots.c hc32f46x_pwc.c hc32f46x_qspi.c hc32f46x_rmu.c hc32f46x_rtc.c hc32f46x_sdioc.c hc32f46x_spi.c hc32f46x_sram.c hc32f46x_swdt.c hc32f46x_timer0.c hc32f46x_timer4_cnt.c hc32f46x_timer4_emb.c hc32f46x_timer4_oco.c hc32f46x_timer4_pwm.c hc32f46x_timer4_sevt.c hc32f46x_timer6.c hc32f46x_timera.c hc32f46x_trng.c hc32f46x_usart.c hc32f46x_utility.c hc32f46x_wdt.c
  group board
    ../source/main/: main.cpp
    ../source/drivers/board/: board_gpio.c
    ./: glib.lib
    ../source/main/hdsc32core/: startup_hc32f460petb.s system_hc32f460petb.c
  group marlin
    ../source/Marlin/: _Bootscreen.h _Statusscreen.h Configuration.h Configuration_adv.h Version.h
    ../source/Marlin/src/: MarlinCore.cpp MarlinCore.h
  group marlin_cores
    ../source/Marlin/src/core/: boards.h bug_on.h debug_out.h debug_section.h drivers.h language.h macros.h millis_t.h multi_language.h serial.cpp serial.h serial_base.h serial_hook.h types.h utility.cpp utility.h
  group marlin_feature
    ../source/Marlin/src/feature/: babystep.cpp babystep.h controllerfan.h fwretract.h pause.h powerloss.cpp powerloss.h twibus.h
  group marlin_gcode
    ../source/Marlin/src/gcode/calibrate/: G28.cpp
    ../source/Marlin/src/gcode/config/: M92.cpp M200-M205.cpp M220.cpp M221.cpp M301.cpp M302.cpp M304.cpp M309.cpp
    ../source/Marlin/src/gcode/control/: M17_M18_M84.cpp M80_M81.cpp M85.cpp M108_M112_M410.cpp M111.cpp M120_M121.cpp M211.cpp M400.cpp M993_M994.cpp M997.cpp M999.cpp T.cpp
    ../source/Marlin/src/gcode/eeprom/: M500-M504.cpp
    ../source/Marlin/src/gcode/feature/digipot/: M907-M910.cpp
    ../source/Marlin/src/gcode/feature/pause/: G27.cpp
    ../source/Marlin/src/gcode/feature/powerloss/: M413.cpp M1000.cpp
    ../source/Marlin/src/gcode/geometry/: G92.cpp M206_M428.cpp
    ../source/Marlin/src/gcode/host/: M110.cpp M113.cpp M114.cpp M115.cpp M118.cpp M119.cpp
    ../source/Marlin/src/gcode/lcd/: M0_M1.cpp M117.cpp M145.cpp M300.cpp M414.cpp
    ../source/Marlin/src/gcode/motion/: G0_G1.cpp G2_G3.cpp G4.cpp M290.cpp
    ../source/Marlin/src/gcode/sd/: M20.cpp M21_M22.cpp M23.cpp M24_M25.cpp M26.cpp M27.cpp M28_M29.cpp M30.cpp M32.cpp M33.cpp M34.cpp M524.cpp M928.cpp M1001.cpp
    ../source/Marlin/src/gcode/stats/: M31.cpp M75-M78.cpp
    ../source/Marlin/src/gcode/temp/: M104_M109.cpp M105.cpp M106_M107.cpp M140_M190.cpp M141_M191.cpp M143_M193.cpp M155.cpp M303.cpp
    ../source/Marlin/src/gcode/units/: M82_M83.cpp
    ../source/Marlin/src/gcode/: gcode.cpp gcode.h gcode_d.cpp parser.cpp parser.h queue.cpp queue.h
  group marlin_HAL
    ../source/Marlin/src/HAL/: HAL.h platforms.h
    ../source/Marlin/src/HAL/shared/cpu_exception/: exception_hook.h
    ../source/Marlin/src/HAL/shared/: Delay.cpp Delay.h eeprom_api.cpp eeprom_api.h eeprom_if.h esp_wifi.cpp esp_wifi.h HAL_SPI.h Marduino.h math_32bit.h progmem.h servo.cpp servo.h servo_private.h HAL_MinSerial.cpp HAL_MinSerial.h
    ../source/Marlin/src/HAL/STM32F1/dogm/: u8g_com_stm32duino_swspi.cpp
    ../source/Marlin/src/HAL/STM32F1/inc/: Conditionals_adv.h Conditionals_LCD.h Conditionals_post.h SanityCheck.h
    ../source/Marlin/src/HAL/STM32F1/tft/: tft_fsmc.cpp tft_fsmc.h tft_spi.cpp tft_spi.h xpt2046.cpp xpt2046.h
    ../source/Marlin/src/HAL/STM32F1/: eeprom_bl24cxx.cpp eeprom_flash.cpp eeprom_if_iic.cpp eeprom_sdcard.cpp eeprom_wired.cpp endstop_interrupts.h fast_pwm.cpp fastio.h HAL.cpp HAL_SPI.cpp pinsDebug.h sdio.cpp SPI.cpp SPI.h spi_pins.h timers.cpp timers.h watchdog.cpp watchdog.h MarlinSerial.cpp MarlinSerial.h MarlinSPI.h msc_sd.cpp msc_sd.h onboard_sd.cpp onboard_sd.h sdio.h
  group marlin_inc
    ../source/Marlin/src/inc/: Conditionals_adv.h Conditionals_LCD.h Conditionals_post.h MarlinConfig.h MarlinConfigPre.h SanityCheck.h Version.h
  group marlin_lcd
    ../source/Marlin/src/lcd/dogm/: dogm_Bootscreen.h dogm_Statusscreen.h HAL_LCD_class_defines.h HAL_LCD_com_defines.h lcdprint_u8g.cpp marlinui_DOGM.cpp marlinui_DOGM.h status_screen_DOGM.cpp status_screen_lite_ST7920.cpp status_screen_lite_ST7920.h u8g_dev_ssd1306_sh1106_128x64_I2C.cpp u8g_dev_ssd1309_12864.cpp u8g_dev_st7565_64128n_HAL.cpp u8g_dev_st7920_128x64_HAL.cpp u8g_dev_tft_upscale_from_128x64.cpp u8g_dev_uc1701_mini12864_HAL.cpp u8g_fontutf8.cpp u8g_fontutf8.h ultralcd_st7920_u8glib_rrd_AVR.cpp ultralcd_st7920_u8glib_rrd_AVR.h
    ../source/Marlin/src/lcd/dwin/: dwin_lcd.cpp dwin_lcd.h
    ../source/Marlin/src/lcd/dwin/e3v2/: dwin.cpp dwin.h rotary_encoder.cpp rotary_encoder.h
    ../source/Marlin/src/lcd/extui/: ui_api.cpp ui_api.h
    ../source/Marlin/src/lcd/menu/: menu.cpp menu.h menu_addon.h menu_advanced.cpp menu_backlash.cpp menu_bed_corners.cpp menu_bed_leveling.cpp menu_cancelobject.cpp menu_configuration.cpp menu_delta_calibrate.cpp menu_filament.cpp menu_game.cpp menu_info.cpp menu_item.h menu_job_recovery.cpp menu_language.cpp menu_led.cpp menu_main.cpp menu_media.cpp menu_mixer.cpp menu_mmu2.cpp menu_mmu2.h menu_motion.cpp menu_password.cpp menu_power_monitor.cpp menu_probe_offset.cpp menu_spindle_laser.cpp menu_temperature.cpp menu_tmc.cpp menu_touch_screen.cpp menu_tramming.cpp menu_tune.cpp menu_ubl.cpp
    ../source/Marlin/src/lcd/: buttons.h fontutils.cpp fontutils.h lcdprint.cpp lcdprint.h marlinui.cpp marlinui.h scaled_tft.h thermistornames.h
    ../source/Marlin/src/lcd/dogm/status/: bed.h chamber.h combined.h cooler.h cutter.h fan.h hotend.h
    ../source/Marlin/src/lcd/dogm/fontdata/: fontdata_6x9_marlin.h fontdata_ISO10646_1.h langdata_an.h langdata_bg.h langdata_ca.h langdata_cz.h langdata_da.h langdata_de.h langdata_el.h langdata_el_gr.h langdata_en.h langdata_es.h langdata_eu.h langdata_fi.h langdata_fr.h langdata_gl.h langdata_hr.h langdata_hu.h langdata_it.h langdata_jp_kana.h langdata_ko_KR.h langdata_nl.h langdata_pl.h langdata_pt.h langdata_pt_br.h langdata_ro.h langdata_ru.h langdata_sk.h langdata_test.h langdata_tr.h langdata_uk.h langdata_vi.h langdata_zh_CN.h langdata_zh_TW.h
    ../source/Marlin/src/lcd/language/: language_an.h language_bg.h language_ca.h language_cz.h language_da.h language_de.h language_el.h language_el_gr.h language_en.h language_es.h language_eu.h language_fi.h language_fr.h language_gl.h language_hr.h language_hu.h language_it.h language_jp_kana.h language_ko_KR.h language_nl.h language_pl.h language_pt.h language_pt_br.h language_ro.h language_ru.h language_sk.h language_sv.h language_test.h language_tr.h language_uk.h language_vi.h language_zh_CN.h language_zh_TW.h
  group marlin_libs
    ../source/Marlin/src/libs/: autoreport.h BL24CXX.cpp BL24CXX.h buzzer.cpp buzzer.h circularqueue.h crc16.cpp crc16.h duration_t.h hex_print.h nozzle.cpp nozzle.h numtostr.cpp numtostr.h stopwatch.cpp stopwatch.h vector_3.cpp vector_3.h
  group marlin_module
    ../source/Marlin/src/module/stepper/: indirection.cpp indirection.h
    ../source/Marlin/src/module/: endstops.cpp endstops.h motion.cpp motion.h planner.cpp planner.h printcounter.h probe.h settings.cpp settings.h stepper.cpp stepper.h temperature.cpp temperature.h tool_change.cpp tool_change.h
  group marlin_pins
    ../source/Marlin/src/pins/stm32f1/: pins_CREALITY_V427.h
    ../source/Marlin/src/pins/: pins.h pins_postprocess.h pinsDebug.h pinsDebug_list.h sensitive_pins.h
  group marlin_sd
    ../source/Marlin/src/sd/: cardreader.cpp cardreader.h disk_io_driver.h Sd2Card.cpp Sd2Card.h Sd2Card_sdio.h SdBaseFile.cpp SdBaseFile.h SdFatConfig.h SdFatStructs.h SdFatUtil.cpp SdFatUtil.h SdFile.cpp SdFile.h SdInfo.h SdVolume.cpp SdVolume.h
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
